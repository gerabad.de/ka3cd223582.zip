Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_4/temp/tmp_3664_25_mLAby/format_2/670-1.ifc
Time: 2023-10-05T07:06:19
Made in: PARTsolutions

# IfcProject, 670-1
Description: Cornezza

# IfcDiscreteAccessory, 670-1
In: BUILDING
Description: 670-1
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: 670-1
ePset_PARTsolutions - NB: 670-1; NN: 670-1; NT: Cornezza; NBSYN: $PRODID.; LINA: 670-1; CATALOG: Kaldewei; PRODID: 670-1; DESCRIPTION_SHORT: Shapes that are reduced to the essentials give us a sense of clarity and simplicity. The Cornezza was born out of this thought. Clear lines for pure shower pleasure. Large footprint for plenty of freedom of movement. And floor-level installation for more elegance in the bathroom.; DESCRIPTION_LONG: Pure shower pleasure; EF000010: Universal; EF000051: Pentagonal; EF020814: true; EF025058: false; EF020363: false; EF002169: -; EF000386: 2,9; EF020621: 23,0; EF001438: 900,0; EF000008: 900,0; EF000040: 32,0; EF001131: 25,0; EF022185: false; EF025073: false; EF025060: false; EF025074: -; EF000007: Beige; EF024897: Glossy; EF025075: false; EF020710: 90,0; EF025068: true; EF025076: false; EF023789: true; EF000139: Enamelled
